LED_FILE_imx7-var-som = "/sys/class/leds/led1/brightness"
LED_FILE_imx8m-var-dart = "/sys/class/leds/led2/brightness"
