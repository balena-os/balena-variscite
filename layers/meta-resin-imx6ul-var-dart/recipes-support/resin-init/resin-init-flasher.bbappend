# On Variscite DART 6UL we flash Resin IO on the emmc
INTERNAL_DEVICE_KERNEL_imx6ul-var-dart = "mmcblk1"
