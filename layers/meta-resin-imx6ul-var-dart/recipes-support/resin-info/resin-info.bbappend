TTYS_append_imx7-var-som = " ttymxc0"
