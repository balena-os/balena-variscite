LED_FILE_imx7-var-som = "/sys/class/leds/led1/brightness"
