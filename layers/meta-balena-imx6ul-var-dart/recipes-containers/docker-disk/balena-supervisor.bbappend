LED_FILE_imx7-var-som = "/sys/class/leds/led1/brightness"
LED_FILE_imx6ul-var-dart = "/sys/class/leds/d16_led/brightness"
