TTYS:append:imx7-var-som = " ttymxc0"
