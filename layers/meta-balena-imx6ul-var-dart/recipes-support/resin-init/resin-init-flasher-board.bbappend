FILESEXTRAPATHS:append:var-som-mx6 := "${THISDIR}/${PN}-var-som-mx6"
