# for flashing balenaOS to the emmc of the respective hardware
INTERNAL_DEVICE_KERNEL:var-som-mx6 = "mmcblk0"
